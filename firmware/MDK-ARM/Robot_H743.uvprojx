# Keil uVision project Robot_H743.uvprojx, settings and files
target Robot_H743 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: robot_h743 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H743xx
  c include: ..\include;..\vendor\CMSIS\Include;..\vendor\CMSIS\Device\ST\STM32H7xx\Include;..\vendor\FreeRTOS\include;..\vendor\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\memory.sct
  group Application
    ../src/: board.c main.c motion.c motion_math.c protocol.c serial.c chassis.c turn.c navigation.c optical_flow.c servo.c
  group CMSIS / RTOS
    ../vendor/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../vendor/FreeRTOS/: tasks.c queue.c list.c
    ../vendor/FreeRTOS/portable/MemMang/: heap_4.c
    ../vendor/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Startup
    ../: startup_stm32h743xx.s
